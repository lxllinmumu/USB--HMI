# Keil uVision project FWPro.uvproj, settings and files
target Target 1 (MCS-51)
  device: EZ-USB FX2LP (CY7C68XXX-X) Cypress Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0xE000-0xE1FF) CLOCK(48000000) MODDP2
  output: FWPro +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: FW.c FWsubfile.c dscr.a51 USBJmpTb.OBJ Ezusb.lib
